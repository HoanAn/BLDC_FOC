# Keil uVision project Firmware_VRTT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Firmware_VRTT
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F0xx, HSE_VALUE=8000000
  c include: .\STM32F0xx_StdPeriph_Driver\inc;..\3phase_inverter
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ./: system_stm32f0xx.c
    D:/HOC TAP/HTDKN/ref/ST/en.stm32f0_stdperiph_lib/STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group User
    ./: main.c PWM_control.c
  group Periph_Driver
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_i2c.c stm32f0xx_tim.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_misc.c
    ./: stm32f0xx_it.c
