# Keil uVision project ThreePhaseInverter.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: ThreePhaseInverter
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F0xx, HSE_VALUE=8000000
  c include: .\STM32F0xx_StdPeriph_Driver\inc;..\bldc_driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./: system_stm32f0xx.c
    D:/An/BLDC_driver/bldc_driver/: startup_stm32f0xx.s
  group User
    ./: main.c PWM_control.c ADC_control.c DMA_control.c I_O_control.c Communication.c
  group Periph_Driver
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_i2c.c stm32f0xx_tim.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_misc.c stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_usart.c
    ./: stm32f0xx_it.c
